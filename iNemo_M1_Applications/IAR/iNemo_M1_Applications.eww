<workspace>
  <project>
    <path>$WS_DIR$\iNemo_M1_Applications.ewp</path>
  </project>
  </workspace>