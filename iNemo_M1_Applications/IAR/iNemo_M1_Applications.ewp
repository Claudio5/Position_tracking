# IAR project iNemo_M1_Applications.ewp, settings and files
configuration AccMag_AccDataReady (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32F10X_HD; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; ..\Source; ..\Source\runtime; ..\..\Sensor_Libraries\LSM303DLHC\inc; ..\..\Sensor_Libraries\L3Gx\inc; ..\..\Sensor_Libraries\LPS331AP\inc; ..\..\iNEMO_M1_SensorDrivers\Source\inc; ..\..\STM32_USB-FS-Device_Lib\Source\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F1_VirtualCom\Source\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ..\Source\runtime\iar
  OBJCOPY.OOCOutputFile: iNemo_M1_Applications.hex
  ILINK.IlinkOutputFile: iNemo_M1_Applications.out
  ILINK.IlinkIcfFile: stm32f10x_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration AccMag_MagDataReady (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration AccMag_Fifo (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration AccMag_Thresholds (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration Gyro_DataReady (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  OBJCOPY.OOCOutputFile: iNEMO_M1_Suite_Engine_Lite.hex
configuration Gyro_Continuous (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration Gyro_Fifo (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration Gyro_Thresholds (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration Press_DataReady (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
configuration AHRS_Lib_Continuous (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: .; ..\Source; ..\Source\runtime; ..\..\Sensor_Libraries\LSM303DLHC\inc; ..\..\Sensor_Libraries\L3Gx\inc; ..\..\Sensor_Libraries\LPS331AP\inc; ..\..\iNEMO_M1_SensorDrivers\Source\inc; ..\..\STM32_USB-FS-Device_Lib\Source\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F1_VirtualCom\Source\inc; ..\..\iNEMO_AHRS_v121\inc
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: iNemo_M1_Applications.srec
  ILINK.IlinkIcfFile: stm32f10x_flash_offset_ExpHeap.icf
  ILINK.IlinkAdditionalLibs: ..\..\iNEMO_AHRS_v121\Nemo_M1_AHRS_Lib_v121.lib
  group iNemo_AHRS_v121/inc
    ../../iNEMO_AHRS_v121/inc/: iNEMO_AHRS.h
  group iNemo_AHRS_v121/src
    ../../iNEMO_AHRS_v121/src/: iNEMO_AHRS_MemMan_1.c
    ../../iNEMO_AHRS_v121/: Nemo_M1_AHRS_Lib_v121.lib
  group iNemo_M1_SensorDrivers/inc
    ../../iNEMO_M1_SensorDrivers/Source/inc/: HAL_L3Gx.h HAL_LPS331AP.h HAL_LSM303DLHC.h iNEMO_I2C_Driver.h iNEMO_SPI_Driver.h
  group iNemo_M1_SensorDrivers/src
    ../../iNEMO_M1_SensorDrivers/Source/src/: iNEMO_I2C_Driver.c iNemo_SPI_Driver.c
  group iNemo_Sensors_Lib/L3Gx/inc
    ../../Sensor_Libraries/L3Gx/inc/: L3Gx.h
  group iNemo_Sensors_Lib/L3Gx/src
    ../../Sensor_Libraries/L3Gx/src/: L3Gx.c
  group iNemo_Sensors_Lib/LPS331AP/inc
    ../../Sensor_Libraries/LPS331AP/inc/: LPS331AP.h
  group iNemo_Sensors_Lib/LPS331AP/src
    ../../Sensor_Libraries/LPS331AP/src/: LPS331AP.c
  group iNemo_Sensors_Lib/LSM303DLHC/inc
    ../../Sensor_Libraries/LSM303DLHC/inc/: LSM303DLHC.h
  group iNemo_Sensors_Lib/LSM303DLHC/src
    ../../Sensor_Libraries/LSM303DLHC/src/: LSM303DLHC.c
  group Runtime_STM32F1xx
    ../Source/runtime/iar/: startup_stm32f10x_hd.s
    ../Source/runtime/: system_stm32f10x.c
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h
  group Source
    ../Source/examples/: AHRS_Lib_Continuous.c L3GD20_Continuous.c L3GD20_DataReady.c L3GD20_Fifo.c L3GD20_Threshold.c LPS331AP_DataReady.c LSM303DLHC_AccDataReady.c LSM303DLHC_Fifo.c LSM303DLHC_MagDataReady.c LSM303DLHC_Thresholds.c
    ../Source/: iNEMO_Led.c iNEMO_Led.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h STM32F1_VC_Conf.h
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group STM32_USB-FS-Device_Lib/inc
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/inc/: otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h otgd_fs_regs.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group STM32_USB-FS-Device_Lib/src
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Lib/inc
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Lib/src
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F1_VirtualCom/inc
    ../../STM32F1_VirtualCom/Source/inc/: STM32F1_VC_Desc.h STM32F1_VC_General.h STM32F1_VC_Istr.h STM32F1_VC_Prop.h STM32F1_VC_Pwr.h usb_conf.h
  group STM32F1_VirtualCom/src
    ../../STM32F1_VirtualCom/Source/src/: STM32F1_VC_Desc.c STM32F1_VC_Endp.c STM32F1_VC_General.c STM32F1_VC_Istr.c STM32F1_VC_Prop.c STM32F1_VC_Pwr.c
