<workspace>
  <project>
    <path>$WS_DIR$\M1_Discovery_System.ewp</path>
  </project>
  </workspace>