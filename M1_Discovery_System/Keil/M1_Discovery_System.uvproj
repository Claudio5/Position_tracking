# Keil uVision project M1_Discovery_System.uvproj, settings and files
target M1_Discovery_System-INEMO-M1AHRS_1.2.1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: iNemoM1_AHRS_1.2.1_lib +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER VECT_TAB_FLASH STM32F10X_HD Enable_SW_Mode USE_DFU KEIL
  c include: ..\Keil;..\Source;..\Source\runtime;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\Keil\ARM_CM3;..\..\iNEMO_Compass\inc;..\..\iNEMO_M1_SensorDrivers\Source\inc;..\..\Sensor_Libraries\L3Gx\inc;..\..\Sensor_Libraries\LPS331AP\inc;..\..\Sensor_Libraries\LSM303DLHC\inc;..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F1_VirtualCom\Source\inc;..\..\STM32_USB-FS-Device_Lib\Source\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\iNEMO_AHRS_v121\inc;..\Source\iNEMO_Conf;..\Source\iNemo_Core;..\Source\iNEMO_Gatekeeper;..\Source\iNEMO_Handlers;..\Source\iNemo_Led;..\Source\iNEMO_Lib;..\..\iNEMO_AHRS_v121\src
  asm include: ..\Keil;..\Source\runtime\keil;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../Source/: FreeRTOSConfig.h
  group FreeRTOS_Include
    ../../FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS_Portable_ARM_CM3
    ../../FreeRTOS/Source/portable/Keil/ARM_CM3/: port.c portmacro.h
  group FreeRTOS_Portable_MemMang
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group iNEMO_AHRS_v121
    ../../iNEMO_AHRS_v121/inc/: iNEMO_AHRS.h
    ../../iNEMO_AHRS_v121/src/: iNEMO_AHRS_MemMan_2.c
    ../../iNEMO_AHRS_v121/: Nemo_M1_AHRS_Lib_v121.lib
  group iNEMO_Compass
    ../../iNEMO_Compass/inc/: iNEMO_Compass.h
    ../../iNEMO_Compass/src/: iNEMO_Compass.c
  group iNEMO_M1_SensorDrivers
    ../../iNEMO_M1_SensorDrivers/Source/inc/: HAL_L3Gx.h HAL_LPS331AP.h HAL_LSM303DLHC.h iNEMO_I2C_Driver.h iNEMO_SPI_Driver.h
    ../../iNEMO_M1_SensorDrivers/Source/src/: iNEMO_I2C_Driver.c iNemo_SPI_Driver.c
  group INEMO_Sensors_Lib
    ../../Sensor_Libraries/L3Gx/inc/: L3Gx.h
    ../../Sensor_Libraries/L3Gx/src/: L3Gx.c
    ../../Sensor_Libraries/LPS331AP/inc/: LPS331AP.h
    ../../Sensor_Libraries/LPS331AP/src/: LPS331AP.c
    ../../Sensor_Libraries/LSM303DLHC/src/: LSM303DLHC.c
    ../../Sensor_Libraries/LSM303DLHC/inc/: LSM303DLHC.h
  group Runtime_STM32F1xx
    ../Source/runtime/keil/: startup_stm32f10x_hd.s
    ../Source/runtime/: system_stm32f10x.c
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h
  group Source_INEMO_Conf
    ../Source/iNEMO_Conf/: iNemoConf.h
  group Source_iNEMO_Core
    ../Source/iNemo_Core/: iNemo.c iNemo.h
  group Source_iNEMO_Gatekeeper
    ../Source/iNEMO_Gatekeeper/: iNemoGatekeeper.h UsbGatekeeper.c
  group Source_iNEMO_Handlers
    ../Source/iNEMO_Handlers/: iNemoHandlers.c iNemoHandlers.h
  group Source_iNEMO_Led
    ../Source/iNemo_Led/: iNemoLed.c iNemoLed.h
  group Source_iNEMO_Lib
    ../Source/iNEMO_Lib/: iNemoLib.c iNemoLib.h
  group Source
    ../Source/: FreeRTOSConfig.h main.c STM32F1_VC_Conf.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h utils.c utils.h
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group STM32_USB-FS-Device_Lib
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/inc/: otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h otgd_fs_regs.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Lib
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F1_VirtualCom
    ../../STM32F1_VirtualCom/Source/inc/: STM32F1_VC_Desc.h STM32F1_VC_General.h STM32F1_VC_Istr.h STM32F1_VC_Prop.h STM32F1_VC_Pwr.h usb_conf.h
    ../../STM32F1_VirtualCom/Source/src/: STM32F1_VC_Desc.c STM32F1_VC_Endp.c STM32F1_VC_General.c STM32F1_VC_Istr.c STM32F1_VC_Prop.c STM32F1_VC_Pwr.c
