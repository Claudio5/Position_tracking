# IAR project iNEMO_DFU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32F10X_HD; IAR_ARM_CM3
  ICCARM.CCIncludePath2: .; ..\..\STM32_USB-FS-Device_Lib\Source\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x_StdPeriph_Lib\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Source; ..\Source\Device_Firmware_Upgrade\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ..\Source\runtime\iar
  OBJCOPY.OOCOutputFile: iNEMO_DFU.hex
  ILINK.IlinkOutputFile: iNEMO_DFU.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group Device_Firmware_Upgrade/inc
    ../Source/Device_Firmware_Upgrade/inc/: iNEMO_DFU_Desc.h iNEMO_DFU_Flash_If.h iNEMO_DFU_General.h iNEMO_DFU_Istr.h iNEMO_DFU_Mal.h iNEMO_DFU_Prop.h iNEMO_DFU_Pwr.h usb_conf.h
  group Device_Firmware_Upgrade/src
    ../Source/Device_Firmware_Upgrade/src/: iNEMO_DFU_Desc.c iNEMO_DFU_Flash_If.c iNEMO_DFU_General.c iNEMO_DFU_Istr.c iNEMO_DFU_Mal.c iNEMO_DFU_Prop.c iNEMO_DFU_Pwr.c
  group Runtime_STM32F1xx
    ../Source/runtime/iar/: startup_stm32f10x_hd.s
    ../Source/runtime/: system_stm32f10x.c
  group Source
    ../Source/: iNEMO_Button.c iNEMO_Button.h iNEMO_Led.c iNEMO_Led.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STM32_USB-FS-Device_Lib/inc
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/inc/: otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h otgd_fs_regs.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group STM32_USB-FS-Device_Lib/src
    ../../STM32_USB-FS-Device_Lib/Source/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Lib/inc
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Lib/src
    ../../STM32F10x_StdPeriph_Lib/Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
